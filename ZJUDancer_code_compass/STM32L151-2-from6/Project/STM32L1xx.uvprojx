# Keil uVision project STM32L1xx.uvprojx, settings and files
target STM32L151 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L1xx
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD,
  c include: ..\Library\StdPeriph_Driver\inc;..\Library\CMSIS;..\Library\StartUp;..\USER;..\My_C\include;..\Library\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS
    ../Library/CMSIS/: system_stm32l1xx.c stm32l1xx.h
  group StartUp
    ../Library/StartUp/: startup_stm32l1xx_md.s
  group StdPeriph_Driver
    ../Library/CMSIS/: system_stm32l1xx.h
    ../Library/StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group USER
    ../USER/: main.c main.h stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h
  group My_C
    ../My_C/: Init.c Interrupt.c Spi.c Timer.c Usart.c
  group Include
    ../My_C/include/: function_conf.h Init.h Interrupt.h main2.h Spi.h Timer.h Usart.h
